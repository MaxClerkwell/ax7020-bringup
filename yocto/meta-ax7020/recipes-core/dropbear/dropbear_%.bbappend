FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:ax7020 = " file://dropbear.default"
